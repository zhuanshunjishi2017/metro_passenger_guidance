<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectOpt xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_optx.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <Extensions>
    <cExt>*.c</cExt>
    <aExt>*.s*; *.src; *.a*</aExt>
    <oExt>*.obj; *.o</oExt>
    <lExt>*.lib</lExt>
    <tExt>*.txt; *.h; *.inc; *.md</tExt>
    <pExt>*.plm</pExt>
    <CppX>*.cpp; *.cc; *.cxx</CppX>
    <nMigrate>0</nMigrate>
  </Extensions>

  <DaveTm>
    <dwLowDateTime>0</dwLowDateTime>
    <dwHighDateTime>0</dwHighDateTime>
  </DaveTm>

  <Target>
    <TargetName>Target 1</TargetName>
    <ToolsetNumber>0x4</ToolsetNumber>
    <ToolsetName>ARM-ADS</ToolsetName>
    <TargetOption>
      <CLKADS>12000000</CLKADS>
      <OPTTT>
        <gFlags>1</gFlags>
        <BeepAtEnd>1</BeepAtEnd>
        <RunSim>0</RunSim>
        <RunTarget>1</RunTarget>
        <RunAbUc>0</RunAbUc>
      </OPTTT>
      <OPTHX>
        <HexSelection>1</HexSelection>
        <FlashByte>65535</FlashByte>
        <HexRangeLowAddress>0</HexRangeLowAddress>
        <HexRangeHighAddress>0</HexRangeHighAddress>
        <HexOffset>0</HexOffset>
      </OPTHX>
      <OPTLEX>
        <PageWidth>79</PageWidth>
        <PageLength>66</PageLength>
        <TabStop>8</TabStop>
        <ListingPath>.\Listings\</ListingPath>
      </OPTLEX>
      <ListingPage>
        <CreateCListing>1</CreateCListing>
        <CreateAListing>1</CreateAListing>
        <CreateLListing>1</CreateLListing>
        <CreateIListing>0</CreateIListing>
        <AsmCond>1</AsmCond>
        <AsmSymb>1</AsmSymb>
        <AsmXref>0</AsmXref>
        <CCond>1</CCond>
        <CCode>0</CCode>
        <CListInc>0</CListInc>
        <CSymb>0</CSymb>
        <LinkerCodeListing>0</LinkerCodeListing>
      </ListingPage>
      <OPTXL>
        <LMap>1</LMap>
        <LComments>1</LComments>
        <LGenerateSymbols>1</LGenerateSymbols>
        <LLibSym>1</LLibSym>
        <LLines>1</LLines>
        <LLocSym>1</LLocSym>
        <LPubSym>1</LPubSym>
        <LXref>0</LXref>
        <LExpSel>0</LExpSel>
      </OPTXL>
      <OPTFL>
        <tvExp>1</tvExp>
        <tvExpOptDlg>0</tvExpOptDlg>
        <IsCurrentTarget>1</IsCurrentTarget>
      </OPTFL>
      <CpuCode>255</CpuCode>
      <DebugOpt>
        <uSim>0</uSim>
        <uTrg>1</uTrg>
        <sLdApp>1</sLdApp>
        <sGomain>1</sGomain>
        <sRbreak>1</sRbreak>
        <sRwatch>1</sRwatch>
        <sRmem>1</sRmem>
        <sRfunc>1</sRfunc>
        <sRbox>1</sRbox>
        <tLdApp>1</tLdApp>
        <tGomain>1</tGomain>
        <tRbreak>1</tRbreak>
        <tRwatch>1</tRwatch>
        <tRmem>1</tRmem>
        <tRfunc>0</tRfunc>
        <tRbox>1</tRbox>
        <tRtrace>1</tRtrace>
        <sRSysVw>1</sRSysVw>
        <tRSysVw>1</tRSysVw>
        <sRunDeb>0</sRunDeb>
        <sLrtime>0</sLrtime>
        <bEvRecOn>1</bEvRecOn>
        <bSchkAxf>0</bSchkAxf>
        <bTchkAxf>0</bTchkAxf>
        <nTsel>3</nTsel>
        <sDll></sDll>
        <sDllPa></sDllPa>
        <sDlgDll></sDlgDll>
        <sDlgPa></sDlgPa>
        <sIfile></sIfile>
        <tDll></tDll>
        <tDllPa></tDllPa>
        <tDlgDll></tDlgDll>
        <tDlgPa></tDlgPa>
        <tIfile></tIfile>
        <pMon>BIN\CMSIS_AGDI.dll</pMon>
      </DebugOpt>
      <TargetDriverDllRegistry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMRTXEVENTFLAGS</Key>
          <Name>-L70 -Z18 -C0 -M0 -T1</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGTARM</Key>
          <Name>(1010=-1,-1,-1,-1,0)(6017=-1,-1,-1,-1,0)(1008=-1,-1,-1,-1,0)(6016=-1,-1,-1,-1,0)(1012=-1,-1,-1,-1,0)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>ARMDBGFLAGS</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>CMSIS_AGDI</Key>
          <Name>-X"" -O206 -S0 -C0 -P00000000 -N00("ARM CoreSight SW-DP") -D00(0BD12477) -L00(0) -TO65554 -TC10000000 -TT10000000 -TP20 -TDS8007 -TDT0 -TDC1F -TIEFFFFFFFF -TIP8 -FO7 -FD24000000 -FC2000 -FN1 -FF0GD32H7xx_3840KB.FLM -FS08000000 -FL03C0000 -FP0($$Device:GD32H759IM$Flash\GD32H7xx_3840KB.FLM)</Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>DLGUARM</Key>
          <Name></Name>
        </SetRegEntry>
        <SetRegEntry>
          <Number>0</Number>
          <Key>UL2CM3</Key>
          <Name>UL2CM3(-S0 -C0 -P0 -FD24000000 -FC2000 -FN1 -FF0GD32H7xx_3840KB -FS08000000 -FL03C0000 -FP0($$Device:GD32H759IM$Flash\GD32H7xx_3840KB.FLM))</Name>
        </SetRegEntry>
      </TargetDriverDllRegistry>
      <Breakpoint>
        <Bp>
          <Number>0</Number>
          <Type>0</Type>
          <LineNumber>34</LineNumber>
          <EnabledFlag>1</EnabledFlag>
          <Address>134235480</Address>
          <ByteObject>0</ByteObject>
          <HtxType>0</HtxType>
          <ManyObjects>0</ManyObjects>
          <SizeOfObject>0</SizeOfObject>
          <BreakByAccess>0</BreakByAccess>
          <BreakIfRCount>1</BreakIfRCount>
          <Filename>.\main\source\displaycanvas.c</Filename>
          <ExecCommand></ExecCommand>
          <Expression>\\TemplateProject\main/source/displaycanvas.c\34</Expression>
        </Bp>
      </Breakpoint>
      <Tracepoint>
        <THDelay>0</THDelay>
      </Tracepoint>
      <DebugFlag>
        <trace>0</trace>
        <periodic>0</periodic>
        <aLwin>1</aLwin>
        <aCover>0</aCover>
        <aSer1>0</aSer1>
        <aSer2>0</aSer2>
        <aPa>0</aPa>
        <viewmode>1</viewmode>
        <vrSel>0</vrSel>
        <aSym>0</aSym>
        <aTbox>0</aTbox>
        <AscS1>0</AscS1>
        <AscS2>0</AscS2>
        <AscS3>0</AscS3>
        <aSer3>0</aSer3>
        <eProf>0</eProf>
        <aLa>0</aLa>
        <aPa1>0</aPa1>
        <AscS4>0</AscS4>
        <aSer4>0</aSer4>
        <StkLoc>0</StkLoc>
        <TrcWin>0</TrcWin>
        <newCpu>0</newCpu>
        <uProt>0</uProt>
      </DebugFlag>
      <LintExecutable></LintExecutable>
      <LintConfigFile></LintConfigFile>
      <bLintAuto>0</bLintAuto>
      <bAutoGenD>0</bAutoGenD>
      <LntExFlags>0</LntExFlags>
      <pMisraName></pMisraName>
      <pszMrule></pszMrule>
      <pSingCmds></pSingCmds>
      <pMultCmds></pMultCmds>
      <pMisraNamep></pMisraNamep>
      <pszMrulep></pszMrulep>
      <pSingCmdsp></pSingCmdsp>
      <pMultCmdsp></pMultCmdsp>
    </TargetOption>
  </Target>

  <Group>
    <GroupName>main\source</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>1</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\main\source\gd32h7xx_it.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_it.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>2</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\main\source\gui.c</PathWithFileName>
      <FilenameWithoutPath>gui.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>3</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\main\source\main.c</PathWithFileName>
      <FilenameWithoutPath>main.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>4</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\main\source\read_file_to_array.c</PathWithFileName>
      <FilenameWithoutPath>read_file_to_array.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>5</FileNumber>
      <FileType>2</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx\startup_gd32h7xx.s</PathWithFileName>
      <FilenameWithoutPath>startup_gd32h7xx.s</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>6</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx\system_gd32h7xx.c</PathWithFileName>
      <FilenameWithoutPath>system_gd32h7xx.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>7</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\main\source\rtc_time.c</PathWithFileName>
      <FilenameWithoutPath>rtc_time.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>8</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
<<<<<<< HEAD
=======
      <PathWithFileName>.\main\source\heiti_14.c</PathWithFileName>
      <FilenameWithoutPath>heiti_14.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>9</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <PathWithFileName>.\main\source\maps.c</PathWithFileName>
      <FilenameWithoutPath>maps.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
<<<<<<< HEAD
=======
    <File>
      <GroupNumber>1</GroupNumber>
      <FileNumber>10</FileNumber>
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\main\source\displaycanvas.c</PathWithFileName>
      <FilenameWithoutPath>displaycanvas.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
  </Group>

  <Group>
    <GroupName>Standard Peripheral</GroupName>
    <tvExp>1</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>9</FileNumber>
=======
      <FileNumber>11</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx_standard_peripheral\Source\gd32h7xx_misc.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_misc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>10</FileNumber>
=======
      <FileNumber>12</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx_standard_peripheral\Source\gd32h7xx_gpio.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_gpio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>11</FileNumber>
=======
      <FileNumber>13</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx_standard_peripheral\Source\gd32h7xx_rcu.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_rcu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>12</FileNumber>
=======
      <FileNumber>14</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx_standard_peripheral\Source\gd32h7xx_tli.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_tli.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>13</FileNumber>
=======
      <FileNumber>15</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx_standard_peripheral\Source\gd32h7xx_exmc.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_exmc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>14</FileNumber>
=======
      <FileNumber>16</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx_standard_peripheral\Source\gd32h7xx_sdio.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_sdio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>15</FileNumber>
=======
      <FileNumber>17</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx_standard_peripheral\Source\gd32h7xx_usart.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_usart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>16</FileNumber>
=======
      <FileNumber>18</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx_standard_peripheral\Source\gd32h7xx_spi.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_spi.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>17</FileNumber>
=======
      <FileNumber>19</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx_standard_peripheral\Source\gd32h7xx_dma.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_dma.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>18</FileNumber>
=======
      <FileNumber>20</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx_standard_peripheral\Source\gd32h7xx_timer.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_timer.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>19</FileNumber>
=======
      <FileNumber>21</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx_standard_peripheral\Source\gd32h7xx_pmu.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_pmu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>2</GroupNumber>
<<<<<<< HEAD
      <FileNumber>20</FileNumber>
=======
      <FileNumber>22</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\GD32H7xx_standard_peripheral\Source\gd32h7xx_rtc.c</PathWithFileName>
      <FilenameWithoutPath>gd32h7xx_rtc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>Drivers</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>21</FileNumber>
=======
      <FileNumber>23</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\Drivers\LCD_tli.c</PathWithFileName>
      <FilenameWithoutPath>LCD_tli.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>22</FileNumber>
=======
      <FileNumber>24</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\Drivers\exmc_sdram.c</PathWithFileName>
      <FilenameWithoutPath>exmc_sdram.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>23</FileNumber>
=======
      <FileNumber>25</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\Drivers\sdcard.c</PathWithFileName>
      <FilenameWithoutPath>sdcard.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>24</FileNumber>
=======
      <FileNumber>26</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\Drivers\touch_gtxx.c</PathWithFileName>
      <FilenameWithoutPath>touch_gtxx.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>25</FileNumber>
=======
      <FileNumber>27</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\Drivers\touch_iic.c</PathWithFileName>
      <FilenameWithoutPath>touch_iic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>26</FileNumber>
=======
      <FileNumber>28</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\Drivers\sys.c</PathWithFileName>
      <FilenameWithoutPath>sys.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>3</GroupNumber>
<<<<<<< HEAD
      <FileNumber>27</FileNumber>
=======
      <FileNumber>29</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\Drivers\heap_4.c</PathWithFileName>
      <FilenameWithoutPath>heap_4.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>FATFS</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>4</GroupNumber>
<<<<<<< HEAD
      <FileNumber>28</FileNumber>
=======
      <FileNumber>30</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\FATFS\diskio.c</PathWithFileName>
      <FilenameWithoutPath>diskio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
<<<<<<< HEAD
      <FileNumber>29</FileNumber>
=======
      <FileNumber>31</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\FATFS\ff.c</PathWithFileName>
      <FilenameWithoutPath>ff.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
<<<<<<< HEAD
      <FileNumber>30</FileNumber>
=======
      <FileNumber>32</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\FATFS\ffsystem.c</PathWithFileName>
      <FilenameWithoutPath>ffsystem.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>4</GroupNumber>
<<<<<<< HEAD
      <FileNumber>31</FileNumber>
=======
      <FileNumber>33</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\FATFS\ffunicode.c</PathWithFileName>
      <FilenameWithoutPath>ffunicode.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>lvgl\examples\porting</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>32</FileNumber>
=======
      <FileNumber>34</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\examples\porting\lv_port_disp_template.c</PathWithFileName>
      <FilenameWithoutPath>lv_port_disp_template.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>5</GroupNumber>
<<<<<<< HEAD
      <FileNumber>33</FileNumber>
=======
      <FileNumber>35</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\examples\porting\lv_port_indev_template.c</PathWithFileName>
      <FilenameWithoutPath>lv_port_indev_template.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>lvgl\src\core</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>34</FileNumber>
=======
      <FileNumber>36</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_disp.c</PathWithFileName>
      <FilenameWithoutPath>lv_disp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>35</FileNumber>
=======
      <FileNumber>37</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_event.c</PathWithFileName>
      <FilenameWithoutPath>lv_event.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>36</FileNumber>
=======
      <FileNumber>38</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_group.c</PathWithFileName>
      <FilenameWithoutPath>lv_group.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>37</FileNumber>
=======
      <FileNumber>39</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_indev.c</PathWithFileName>
      <FilenameWithoutPath>lv_indev.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>38</FileNumber>
=======
      <FileNumber>40</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_indev_scroll.c</PathWithFileName>
      <FilenameWithoutPath>lv_indev_scroll.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>39</FileNumber>
=======
      <FileNumber>41</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_obj.c</PathWithFileName>
      <FilenameWithoutPath>lv_obj.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>40</FileNumber>
=======
      <FileNumber>42</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_obj_class.c</PathWithFileName>
      <FilenameWithoutPath>lv_obj_class.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>41</FileNumber>
=======
      <FileNumber>43</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_obj_draw.c</PathWithFileName>
      <FilenameWithoutPath>lv_obj_draw.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>42</FileNumber>
=======
      <FileNumber>44</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_obj_pos.c</PathWithFileName>
      <FilenameWithoutPath>lv_obj_pos.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>43</FileNumber>
=======
      <FileNumber>45</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_obj_scroll.c</PathWithFileName>
      <FilenameWithoutPath>lv_obj_scroll.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>44</FileNumber>
=======
      <FileNumber>46</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_obj_style.c</PathWithFileName>
      <FilenameWithoutPath>lv_obj_style.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>45</FileNumber>
=======
      <FileNumber>47</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_obj_style_gen.c</PathWithFileName>
      <FilenameWithoutPath>lv_obj_style_gen.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>46</FileNumber>
=======
      <FileNumber>48</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_obj_tree.c</PathWithFileName>
      <FilenameWithoutPath>lv_obj_tree.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>47</FileNumber>
=======
      <FileNumber>49</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_refr.c</PathWithFileName>
      <FilenameWithoutPath>lv_refr.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>6</GroupNumber>
<<<<<<< HEAD
      <FileNumber>48</FileNumber>
=======
      <FileNumber>50</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\core\lv_theme.c</PathWithFileName>
      <FilenameWithoutPath>lv_theme.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>lvgl\src\draw</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>49</FileNumber>
=======
      <FileNumber>51</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\lv_draw.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>50</FileNumber>
=======
      <FileNumber>52</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\lv_draw_arc.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_arc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>51</FileNumber>
=======
      <FileNumber>53</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\lv_draw_img.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_img.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>52</FileNumber>
=======
      <FileNumber>54</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\lv_draw_label.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_label.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>53</FileNumber>
=======
      <FileNumber>55</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\lv_draw_line.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_line.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>54</FileNumber>
=======
      <FileNumber>56</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\lv_draw_mask.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_mask.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>55</FileNumber>
=======
      <FileNumber>57</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\lv_draw_rect.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_rect.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>56</FileNumber>
=======
      <FileNumber>58</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\lv_draw_triangle.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_triangle.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>57</FileNumber>
=======
      <FileNumber>59</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\lv_img_buf.c</PathWithFileName>
      <FilenameWithoutPath>lv_img_buf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>58</FileNumber>
=======
      <FileNumber>60</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\lv_img_cache.c</PathWithFileName>
      <FilenameWithoutPath>lv_img_cache.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>59</FileNumber>
=======
      <FileNumber>61</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\lv_img_decoder.c</PathWithFileName>
      <FilenameWithoutPath>lv_img_decoder.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>60</FileNumber>
=======
      <FileNumber>62</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sw\lv_draw_sw.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sw.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>61</FileNumber>
=======
      <FileNumber>63</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sw\lv_draw_sw_arc.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sw_arc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>62</FileNumber>
=======
      <FileNumber>64</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sw\lv_draw_sw_blend.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sw_blend.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>63</FileNumber>
=======
      <FileNumber>65</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sw\lv_draw_sw_dither.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sw_dither.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>64</FileNumber>
=======
      <FileNumber>66</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sw\lv_draw_sw_gradient.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sw_gradient.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>65</FileNumber>
=======
      <FileNumber>67</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sw\lv_draw_sw_img.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sw_img.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>66</FileNumber>
=======
      <FileNumber>68</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sw\lv_draw_sw_letter.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sw_letter.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>67</FileNumber>
=======
      <FileNumber>69</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sw\lv_draw_sw_line.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sw_line.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>68</FileNumber>
=======
      <FileNumber>70</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sw\lv_draw_sw_polygon.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sw_polygon.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>7</GroupNumber>
<<<<<<< HEAD
      <FileNumber>69</FileNumber>
=======
      <FileNumber>71</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sw\lv_draw_sw_rect.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sw_rect.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>lvgl\src\extra</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>70</FileNumber>
=======
      <FileNumber>72</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\layouts\flex\lv_flex.c</PathWithFileName>
      <FilenameWithoutPath>lv_flex.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>71</FileNumber>
=======
      <FileNumber>73</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\layouts\grid\lv_grid.c</PathWithFileName>
      <FilenameWithoutPath>lv_grid.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>72</FileNumber>
=======
      <FileNumber>74</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\bmp\lv_bmp.c</PathWithFileName>
      <FilenameWithoutPath>lv_bmp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>73</FileNumber>
=======
      <FileNumber>75</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\ffmpeg\lv_ffmpeg.c</PathWithFileName>
      <FilenameWithoutPath>lv_ffmpeg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>74</FileNumber>
=======
      <FileNumber>76</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\freetype\lv_freetype.c</PathWithFileName>
      <FilenameWithoutPath>lv_freetype.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>75</FileNumber>
=======
      <FileNumber>77</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\fsdrv\lv_fs_fatfs.c</PathWithFileName>
      <FilenameWithoutPath>lv_fs_fatfs.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>76</FileNumber>
=======
      <FileNumber>78</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\fsdrv\lv_fs_posix.c</PathWithFileName>
      <FilenameWithoutPath>lv_fs_posix.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>77</FileNumber>
=======
      <FileNumber>79</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\fsdrv\lv_fs_stdio.c</PathWithFileName>
      <FilenameWithoutPath>lv_fs_stdio.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>78</FileNumber>
=======
      <FileNumber>80</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\fsdrv\lv_fs_win32.c</PathWithFileName>
      <FilenameWithoutPath>lv_fs_win32.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>79</FileNumber>
=======
      <FileNumber>81</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\gif\gifdec.c</PathWithFileName>
      <FilenameWithoutPath>gifdec.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>80</FileNumber>
=======
      <FileNumber>82</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\gif\lv_gif.c</PathWithFileName>
      <FilenameWithoutPath>lv_gif.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>81</FileNumber>
=======
      <FileNumber>83</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\png\lodepng.c</PathWithFileName>
      <FilenameWithoutPath>lodepng.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>82</FileNumber>
=======
      <FileNumber>84</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\png\lv_png.c</PathWithFileName>
      <FilenameWithoutPath>lv_png.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>83</FileNumber>
=======
      <FileNumber>85</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\qrcode\lv_qrcode.c</PathWithFileName>
      <FilenameWithoutPath>lv_qrcode.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>84</FileNumber>
=======
      <FileNumber>86</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\qrcode\qrcodegen.c</PathWithFileName>
      <FilenameWithoutPath>qrcodegen.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>85</FileNumber>
=======
      <FileNumber>87</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\rlottie\lv_rlottie.c</PathWithFileName>
      <FilenameWithoutPath>lv_rlottie.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>86</FileNumber>
=======
      <FileNumber>88</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\sjpg\lv_sjpg.c</PathWithFileName>
      <FilenameWithoutPath>lv_sjpg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>87</FileNumber>
=======
      <FileNumber>89</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\libs\sjpg\tjpgd.c</PathWithFileName>
      <FilenameWithoutPath>tjpgd.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>88</FileNumber>
=======
      <FileNumber>90</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\others\gridnav\lv_gridnav.c</PathWithFileName>
      <FilenameWithoutPath>lv_gridnav.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>89</FileNumber>
=======
      <FileNumber>91</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\others\monkey\lv_monkey.c</PathWithFileName>
      <FilenameWithoutPath>lv_monkey.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>90</FileNumber>
=======
      <FileNumber>92</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\others\snapshot\lv_snapshot.c</PathWithFileName>
      <FilenameWithoutPath>lv_snapshot.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>91</FileNumber>
=======
      <FileNumber>93</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\themes\basic\lv_theme_basic.c</PathWithFileName>
      <FilenameWithoutPath>lv_theme_basic.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>92</FileNumber>
=======
      <FileNumber>94</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\themes\default\lv_theme_default.c</PathWithFileName>
      <FilenameWithoutPath>lv_theme_default.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>93</FileNumber>
=======
      <FileNumber>95</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\themes\mono\lv_theme_mono.c</PathWithFileName>
      <FilenameWithoutPath>lv_theme_mono.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>94</FileNumber>
=======
      <FileNumber>96</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\animimg\lv_animimg.c</PathWithFileName>
      <FilenameWithoutPath>lv_animimg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>95</FileNumber>
=======
      <FileNumber>97</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\calendar\lv_calendar.c</PathWithFileName>
      <FilenameWithoutPath>lv_calendar.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>96</FileNumber>
=======
      <FileNumber>98</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\calendar\lv_calendar_header_arrow.c</PathWithFileName>
      <FilenameWithoutPath>lv_calendar_header_arrow.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>97</FileNumber>
=======
      <FileNumber>99</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\calendar\lv_calendar_header_dropdown.c</PathWithFileName>
      <FilenameWithoutPath>lv_calendar_header_dropdown.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>98</FileNumber>
=======
      <FileNumber>100</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\chart\lv_chart.c</PathWithFileName>
      <FilenameWithoutPath>lv_chart.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>99</FileNumber>
=======
      <FileNumber>101</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\colorwheel\lv_colorwheel.c</PathWithFileName>
      <FilenameWithoutPath>lv_colorwheel.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>100</FileNumber>
=======
      <FileNumber>102</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\imgbtn\lv_imgbtn.c</PathWithFileName>
      <FilenameWithoutPath>lv_imgbtn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>101</FileNumber>
=======
      <FileNumber>103</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\keyboard\lv_keyboard.c</PathWithFileName>
      <FilenameWithoutPath>lv_keyboard.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>102</FileNumber>
=======
      <FileNumber>104</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\led\lv_led.c</PathWithFileName>
      <FilenameWithoutPath>lv_led.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>103</FileNumber>
=======
      <FileNumber>105</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\list\lv_list.c</PathWithFileName>
      <FilenameWithoutPath>lv_list.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>104</FileNumber>
=======
      <FileNumber>106</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\menu\lv_menu.c</PathWithFileName>
      <FilenameWithoutPath>lv_menu.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>105</FileNumber>
=======
      <FileNumber>107</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\meter\lv_meter.c</PathWithFileName>
      <FilenameWithoutPath>lv_meter.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>106</FileNumber>
=======
      <FileNumber>108</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\msgbox\lv_msgbox.c</PathWithFileName>
      <FilenameWithoutPath>lv_msgbox.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>107</FileNumber>
=======
      <FileNumber>109</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\span\lv_span.c</PathWithFileName>
      <FilenameWithoutPath>lv_span.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>108</FileNumber>
=======
      <FileNumber>110</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\spinbox\lv_spinbox.c</PathWithFileName>
      <FilenameWithoutPath>lv_spinbox.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>109</FileNumber>
=======
      <FileNumber>111</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\spinner\lv_spinner.c</PathWithFileName>
      <FilenameWithoutPath>lv_spinner.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>110</FileNumber>
=======
      <FileNumber>112</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\tabview\lv_tabview.c</PathWithFileName>
      <FilenameWithoutPath>lv_tabview.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>111</FileNumber>
=======
      <FileNumber>113</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\tileview\lv_tileview.c</PathWithFileName>
      <FilenameWithoutPath>lv_tileview.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>112</FileNumber>
=======
      <FileNumber>114</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\widgets\win\lv_win.c</PathWithFileName>
      <FilenameWithoutPath>lv_win.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>8</GroupNumber>
<<<<<<< HEAD
      <FileNumber>113</FileNumber>
=======
      <FileNumber>115</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\extra\lv_extra.c</PathWithFileName>
      <FilenameWithoutPath>lv_extra.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>lvgl\src\font</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>114</FileNumber>
=======
      <FileNumber>116</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font.c</PathWithFileName>
      <FilenameWithoutPath>lv_font.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>115</FileNumber>
=======
      <FileNumber>117</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_dejavu_16_persian_hebrew.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_dejavu_16_persian_hebrew.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>116</FileNumber>
=======
      <FileNumber>118</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_fmt_txt.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_fmt_txt.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>117</FileNumber>
=======
      <FileNumber>119</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_loader.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_loader.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>118</FileNumber>
=======
      <FileNumber>120</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_8.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_8.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>119</FileNumber>
=======
      <FileNumber>121</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_10.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_10.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>120</FileNumber>
=======
      <FileNumber>122</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_12.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_12.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>121</FileNumber>
=======
      <FileNumber>123</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_12_subpx.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_12_subpx.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>122</FileNumber>
=======
      <FileNumber>124</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_14.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_14.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>123</FileNumber>
=======
      <FileNumber>125</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_16.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_16.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>124</FileNumber>
=======
      <FileNumber>126</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_18.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_18.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>125</FileNumber>
=======
      <FileNumber>127</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_20.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_20.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>126</FileNumber>
=======
      <FileNumber>128</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_22.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_22.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>127</FileNumber>
=======
      <FileNumber>129</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_24.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_24.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>128</FileNumber>
=======
      <FileNumber>130</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_26.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_26.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>129</FileNumber>
=======
      <FileNumber>131</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_28.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_28.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>130</FileNumber>
=======
      <FileNumber>132</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_28_compressed.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_28_compressed.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>131</FileNumber>
=======
      <FileNumber>133</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_30.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_30.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>132</FileNumber>
=======
      <FileNumber>134</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_32.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_32.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>133</FileNumber>
=======
      <FileNumber>135</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_34.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_34.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>134</FileNumber>
=======
      <FileNumber>136</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_36.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_36.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>135</FileNumber>
=======
      <FileNumber>137</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_38.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_38.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>136</FileNumber>
=======
      <FileNumber>138</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_40.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_40.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>137</FileNumber>
=======
      <FileNumber>139</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_42.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_42.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>138</FileNumber>
=======
      <FileNumber>140</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_44.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_44.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>139</FileNumber>
=======
      <FileNumber>141</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_46.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_46.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>140</FileNumber>
=======
      <FileNumber>142</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_montserrat_48.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_montserrat_48.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>141</FileNumber>
=======
      <FileNumber>143</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_simsun_16_cjk.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_simsun_16_cjk.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>142</FileNumber>
=======
      <FileNumber>144</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_unscii_8.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_unscii_8.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>9</GroupNumber>
<<<<<<< HEAD
      <FileNumber>143</FileNumber>
=======
      <FileNumber>145</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\font\lv_font_unscii_16.c</PathWithFileName>
      <FilenameWithoutPath>lv_font_unscii_16.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>lvgl\src\gpu</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>144</FileNumber>
=======
      <FileNumber>146</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>145</FileNumber>
=======
      <FileNumber>147</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl_arc.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl_arc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>146</FileNumber>
=======
      <FileNumber>148</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl_bg.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl_bg.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>147</FileNumber>
=======
      <FileNumber>149</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl_composite.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl_composite.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>148</FileNumber>
=======
      <FileNumber>150</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl_img.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl_img.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>149</FileNumber>
=======
      <FileNumber>151</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl_label.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl_label.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>150</FileNumber>
=======
      <FileNumber>152</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl_line.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl_line.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>151</FileNumber>
=======
      <FileNumber>153</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl_mask.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl_mask.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>152</FileNumber>
=======
      <FileNumber>154</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl_polygon.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl_polygon.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>153</FileNumber>
=======
      <FileNumber>155</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl_rect.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl_rect.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>154</FileNumber>
=======
      <FileNumber>156</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl_stack_blur.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl_stack_blur.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>155</FileNumber>
=======
      <FileNumber>157</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl_texture_cache.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl_texture_cache.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>10</GroupNumber>
<<<<<<< HEAD
      <FileNumber>156</FileNumber>
=======
      <FileNumber>158</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\draw\sdl\lv_draw_sdl_utils.c</PathWithFileName>
      <FilenameWithoutPath>lv_draw_sdl_utils.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>lvgl\src\hal</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>11</GroupNumber>
<<<<<<< HEAD
      <FileNumber>157</FileNumber>
=======
      <FileNumber>159</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\hal\lv_hal_disp.c</PathWithFileName>
      <FilenameWithoutPath>lv_hal_disp.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
<<<<<<< HEAD
      <FileNumber>158</FileNumber>
=======
      <FileNumber>160</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\hal\lv_hal_indev.c</PathWithFileName>
      <FilenameWithoutPath>lv_hal_indev.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>11</GroupNumber>
<<<<<<< HEAD
      <FileNumber>159</FileNumber>
=======
      <FileNumber>161</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\hal\lv_hal_tick.c</PathWithFileName>
      <FilenameWithoutPath>lv_hal_tick.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>lvgl\src\misc</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>160</FileNumber>
=======
      <FileNumber>162</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_anim.c</PathWithFileName>
      <FilenameWithoutPath>lv_anim.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>161</FileNumber>
=======
      <FileNumber>163</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_anim_timeline.c</PathWithFileName>
      <FilenameWithoutPath>lv_anim_timeline.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>162</FileNumber>
=======
      <FileNumber>164</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_area.c</PathWithFileName>
      <FilenameWithoutPath>lv_area.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>163</FileNumber>
=======
      <FileNumber>165</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_async.c</PathWithFileName>
      <FilenameWithoutPath>lv_async.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>164</FileNumber>
=======
      <FileNumber>166</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_bidi.c</PathWithFileName>
      <FilenameWithoutPath>lv_bidi.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>165</FileNumber>
=======
      <FileNumber>167</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_color.c</PathWithFileName>
      <FilenameWithoutPath>lv_color.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>166</FileNumber>
=======
      <FileNumber>168</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_fs.c</PathWithFileName>
      <FilenameWithoutPath>lv_fs.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>167</FileNumber>
=======
      <FileNumber>169</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_gc.c</PathWithFileName>
      <FilenameWithoutPath>lv_gc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>168</FileNumber>
=======
      <FileNumber>170</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_ll.c</PathWithFileName>
      <FilenameWithoutPath>lv_ll.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>169</FileNumber>
=======
      <FileNumber>171</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_log.c</PathWithFileName>
      <FilenameWithoutPath>lv_log.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>170</FileNumber>
=======
      <FileNumber>172</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_lru.c</PathWithFileName>
      <FilenameWithoutPath>lv_lru.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>171</FileNumber>
=======
      <FileNumber>173</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_math.c</PathWithFileName>
      <FilenameWithoutPath>lv_math.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>172</FileNumber>
=======
      <FileNumber>174</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_mem.c</PathWithFileName>
      <FilenameWithoutPath>lv_mem.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>173</FileNumber>
=======
      <FileNumber>175</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_printf.c</PathWithFileName>
      <FilenameWithoutPath>lv_printf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>174</FileNumber>
=======
      <FileNumber>176</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_style.c</PathWithFileName>
      <FilenameWithoutPath>lv_style.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>175</FileNumber>
=======
      <FileNumber>177</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_style_gen.c</PathWithFileName>
      <FilenameWithoutPath>lv_style_gen.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>176</FileNumber>
=======
      <FileNumber>178</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_templ.c</PathWithFileName>
      <FilenameWithoutPath>lv_templ.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>177</FileNumber>
=======
      <FileNumber>179</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_timer.c</PathWithFileName>
      <FilenameWithoutPath>lv_timer.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>178</FileNumber>
=======
      <FileNumber>180</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_tlsf.c</PathWithFileName>
      <FilenameWithoutPath>lv_tlsf.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>179</FileNumber>
=======
      <FileNumber>181</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_txt.c</PathWithFileName>
      <FilenameWithoutPath>lv_txt.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>180</FileNumber>
=======
      <FileNumber>182</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_txt_ap.c</PathWithFileName>
      <FilenameWithoutPath>lv_txt_ap.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>12</GroupNumber>
<<<<<<< HEAD
      <FileNumber>181</FileNumber>
=======
      <FileNumber>183</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\misc\lv_utils.c</PathWithFileName>
      <FilenameWithoutPath>lv_utils.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

  <Group>
    <GroupName>lvgl\src\widgets</GroupName>
    <tvExp>0</tvExp>
    <tvExpOptDlg>0</tvExpOptDlg>
    <cbSel>0</cbSel>
    <RteFlg>0</RteFlg>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>182</FileNumber>
=======
      <FileNumber>184</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_arc.c</PathWithFileName>
      <FilenameWithoutPath>lv_arc.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>183</FileNumber>
=======
      <FileNumber>185</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_bar.c</PathWithFileName>
      <FilenameWithoutPath>lv_bar.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>184</FileNumber>
=======
      <FileNumber>186</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_btn.c</PathWithFileName>
      <FilenameWithoutPath>lv_btn.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>185</FileNumber>
=======
      <FileNumber>187</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_btnmatrix.c</PathWithFileName>
      <FilenameWithoutPath>lv_btnmatrix.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>186</FileNumber>
=======
      <FileNumber>188</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_canvas.c</PathWithFileName>
      <FilenameWithoutPath>lv_canvas.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>187</FileNumber>
=======
      <FileNumber>189</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_checkbox.c</PathWithFileName>
      <FilenameWithoutPath>lv_checkbox.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>188</FileNumber>
=======
      <FileNumber>190</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_dropdown.c</PathWithFileName>
      <FilenameWithoutPath>lv_dropdown.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>189</FileNumber>
=======
      <FileNumber>191</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_img.c</PathWithFileName>
      <FilenameWithoutPath>lv_img.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>190</FileNumber>
=======
      <FileNumber>192</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_label.c</PathWithFileName>
      <FilenameWithoutPath>lv_label.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>191</FileNumber>
=======
      <FileNumber>193</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_line.c</PathWithFileName>
      <FilenameWithoutPath>lv_line.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>192</FileNumber>
=======
      <FileNumber>194</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_objx_templ.c</PathWithFileName>
      <FilenameWithoutPath>lv_objx_templ.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>193</FileNumber>
=======
      <FileNumber>195</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_roller.c</PathWithFileName>
      <FilenameWithoutPath>lv_roller.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>194</FileNumber>
=======
      <FileNumber>196</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_slider.c</PathWithFileName>
      <FilenameWithoutPath>lv_slider.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>195</FileNumber>
=======
      <FileNumber>197</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_switch.c</PathWithFileName>
      <FilenameWithoutPath>lv_switch.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>196</FileNumber>
=======
      <FileNumber>198</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_table.c</PathWithFileName>
      <FilenameWithoutPath>lv_table.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
    <File>
      <GroupNumber>13</GroupNumber>
<<<<<<< HEAD
      <FileNumber>197</FileNumber>
=======
      <FileNumber>199</FileNumber>
>>>>>>> c739319d4c792866ba441a2f923c8e51a25d18cb
      <FileType>1</FileType>
      <tvExp>0</tvExp>
      <tvExpOptDlg>0</tvExpOptDlg>
      <bDave2>0</bDave2>
      <PathWithFileName>.\lvgl\src\widgets\lv_textarea.c</PathWithFileName>
      <FilenameWithoutPath>lv_textarea.c</FilenameWithoutPath>
      <RteFlg>0</RteFlg>
      <bShared>0</bShared>
    </File>
  </Group>

</ProjectOpt>
